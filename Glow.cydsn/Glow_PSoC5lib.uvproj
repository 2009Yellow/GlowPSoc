# Keil uVision project Glow_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Glow_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h UART.c UART.h UART_PM.c UART_INT.c tx_int.c tx_int.h rx_int.c rx_int.h TX_aliases.h TX.c TX.h ADC_SAR_1.c ADC_SAR_1.h ADC_SAR_1_INT.c ADC_SAR_1_PM.c ADC_SAR_1_theACLK.c ADC_SAR_1_theACLK.h ADC_SAR_1_Bypass_aliases.h ADC_SAR_1_Bypass.c ADC_SAR_1_Bypass.h VDAC8_REF.c VDAC8_REF.h VDAC8_REF_PM.c PGA_GAIN.c PGA_GAIN.h PGA_GAIN_PM.c PGA_REF.c PGA_REF.h PGA_REF_PM.c IDAC8_REF.c IDAC8_REF.h IDAC8_REF_PM.c TOP_1_aliases.h TOP_1.c TOP_1.h TOP_2_aliases.h TOP_2.c TOP_2.h TOP_3_aliases.h TOP_3.c TOP_3.h TOP_4_aliases.h TOP_4.c TOP_4.h BOTTOM_1_aliases.h BOTTOM_1.c BOTTOM_1.h BOTTOM_2_aliases.h BOTTOM_2.c BOTTOM_2.h BOTTOM_3_aliases.h BOTTOM_3.c BOTTOM_3.h BOTTOM_4_aliases.h BOTTOM_4.c BOTTOM_4.h TOP_MUX_VREF.c TOP_MUX_VREF.h BOTTOM_MUX_GND.c BOTTOM_MUX_GND.h BOTTOM_MUX_SENSE.c BOTTOM_MUX_SENSE.h TOP_MUX_GND.c TOP_MUX_GND.h PGA_BOTTOM_GND.c PGA_BOTTOM_GND.h PGA_BOTTOM_GND_PM.c PGA_TOP_GND.c PGA_TOP_GND.h PGA_TOP_GND_PM.c TOP_5_aliases.h TOP_5.c TOP_5.h BOTTOM_5_aliases.h BOTTOM_5.c BOTTOM_5.h BOTTOM_6_aliases.h BOTTOM_6.c BOTTOM_6.h BOTTOM_7_aliases.h BOTTOM_7.c BOTTOM_7.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Glow_PSoC5lib (library)
